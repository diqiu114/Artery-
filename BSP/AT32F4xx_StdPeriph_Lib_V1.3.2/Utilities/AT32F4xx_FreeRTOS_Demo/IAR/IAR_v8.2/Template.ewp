# IAR project Template.ewp, settings and files
configuration freertos_demo_415 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415C8T7 ArteryTek AT32F415C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415C8T7; USE_STDPERIPH_DRIVER; AT_START_F415_V1_0; SYSCLK_FREQ_144MHz=144000000
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..; ..\..\..\..\Project\AT32_Board; ..\..\..\..\Middlewares\FreeRTOS\Source\include; ..\..\inc; ..\..\..\..\Middlewares\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\inc
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration freertos_demo_413 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RC ArteryTek AT32F413RC
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413Rx_HD; USE_STDPERIPH_DRIVER; AT_START_F413_V1_0; SYSCLK_FREQ_144MHz=144000000
configuration freertos_demo_421 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1_0; SYSCLK_FREQ_120MHz=120000000
  ICCARM.CCOptLevel: 1
configuration freertos_demo_403a (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F403AVGT7 ArteryTek AT32F403AVGT7
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1_0; SYSCLK_FREQ_240MHz=240000000
configuration freertos_demo_407 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F407VGT7 ArteryTek AT32F407VGT7
  General.FPU2: 4
  ICCARM.CCDefines: AT32F407VGT7; USE_STDPERIPH_DRIVER; AT_START_F407_V1_0; SYSCLK_FREQ_240MHz=240000000
configuration freertos_demo_403 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F403ZGT6_v2 ArteryTek - AT32F403ZGT6
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403Zx_HD; USE_STDPERIPH_DRIVER; AT_START_F403_V1_2; SYSCLK_FREQ_192MHz=192000000
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group BSP
    ../../../../Project/AT32_Board/: at32_board.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f403avgt7.s startup_at32f403zx_hd.s startup_at32f407avgt7.s startup_at32f413rx_hd.s startup_at32f415c8t7.s startup_at32f421c8t7.s
    ../../src/: system_at32f4xx.c
  group FreeRTOS
    ../../../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
    ../../../../Middlewares/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group README
    ../: readme.txt
  group USER
    ../../src/: at32f4xx_it.c main.c
