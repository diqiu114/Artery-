# Keil uVision project AT32_FreeRTOS_Demo.uvprojx, settings and files
target FreeRTOS_Demo_403A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F40x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0,SYSCLK_FREQ_240MHz=240000000
  c include: ..\inc;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Project\AT32_Board;..\..\..\Middlewares\FreeRTOS\Source\include;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Drivers/BSP
    ../../../Project/AT32_Board/: at32_board.c
  group Drivers/CMSIS
    ../src/: system_at32f4xx.c
    ../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s startup_at32f407vgt7.s startup_at32f403zx_hd.s startup_at32f413rx_hd.s startup_at32f415rct7.s startup_at32f421c8t7.s
  group User
    ../src/: at32f4xx_it.c main.c
  group Drivers/AT32Periph
    ../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_usart.c at32f4xx_rcc.c misc.c
  group Source/FreeRTOS
    ../../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port_nofpu.c
  group Doc
    ../: readme.txt
target FreeRTOS_Demo_407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F40x_DFP.1.0.0
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0,USE_STDPERIPH_DRIVER,SYSCLK_FREQ_240MHz=240000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target FreeRTOS_Demo_403 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2,SYSCLK_FREQ_192MHz=192000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target FreeRTOS_Demo_413 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0,SYSCLK_FREQ_144MHz=144000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target FreeRTOS_Demo_415 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415C8T7,USE_STDPERIPH_DRIVER,AT_START_F415_V1_0,SYSCLK_FREQ_144MHz=144000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
target FreeRTOS_Demo_421 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0,SYSCLK_FREQ_120MHz=120000000
  c include: ..\inc;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Project\AT32_Board;..\..\..\Middlewares\FreeRTOS\Source\include;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
