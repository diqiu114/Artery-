# Keil uVision project sysmem_iap_bootloader.uvprojx, settings and files
target AT_START_F415 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: sysmem_iap_bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0
  c include: ..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\SYSMEM_IAP_Bootloader;..\..\..\..\..\Project\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x1fffac00 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415rct7.s startup_at32f421c8t7.s
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group BSP
    ../../../../../Project/AT32_Board/: at32_board.c
  group README
    ../: readme.txt
target AT_START_F421 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: sysmem_iap_bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F421_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1fffe400 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
