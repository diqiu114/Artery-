# Keil uVision project XMC.uvprojx, settings and files
target XMC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F40x_DFP.1.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XMC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\AT32_Board;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_tim.c at32f4xx_xmc.c misc.c at32f4xx_usart.c at32f4xx_rcc.c at32f4xx_spi.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/: touch.c xmc_lcd.c
