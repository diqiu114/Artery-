# Keil uVision project TimeOverflow_Interrupt.uvprojx, settings and files
target TimeOverflow_Interrupt (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TimeOverflow_Interrupt +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\TimeOverflow_Interrupt;..\..\..\..\..\AT32_Board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c misc.c
  group README
    ../: readme.txt
