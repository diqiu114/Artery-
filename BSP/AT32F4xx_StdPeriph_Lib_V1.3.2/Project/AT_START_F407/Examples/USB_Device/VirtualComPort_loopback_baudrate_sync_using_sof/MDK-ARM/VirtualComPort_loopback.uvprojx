# Keil uVision project VirtualComPort_loopback.uvprojx, settings and files
target AT32_USB_VirtualComPort_loopback (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB_Virtual_ComPort +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\inc;..\..\..\..\..\AT32_Board;..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Middlewares\AT32_USB-FS-Device_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ../src/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_endp.c main.c at32f4xx_it.c system_at32f4xx.c
  group CMSIS
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group USB-FS-Device-Driver
    ../../../../../../Middlewares/AT32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group AT32F4xx_StdPeriph_Driver
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_exti.c misc.c at32f4xx_usart.c at32f4xx_rcc.c at32f4xx_acc.c at32f4xx_tim.c
